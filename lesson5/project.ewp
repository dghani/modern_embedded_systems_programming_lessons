# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group inc
    inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h
